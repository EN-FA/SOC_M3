# Keil uVision project soc_m3.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: soc_m3
  AfterMake: fromelf -cvf .\Objects\soc_m3.axf --vhx --32x1 -o image.hex
  AfterMake: fromelf -cvf .\Objects\soc_m3.axf -o image.txt
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\sys;..\4_software
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x30000
  group startup
    ./: startup_CM3DS.s
  group main
    ./: main.c
  group sys
    ./sys/: sys.c uart.c
